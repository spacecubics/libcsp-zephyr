## testcase.yaml
```yaml
tests:
  libraries.libcsp:
    integration_platforms:
      - qemu_cortex_m3
      - mps2/an385
    tags: libcsp
```
